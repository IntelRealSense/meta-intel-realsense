FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://remove-redundant-soabi-checks.patch"

