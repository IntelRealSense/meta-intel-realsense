require realsense-linux-5.10.inc