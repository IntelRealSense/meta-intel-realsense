require realsense-linux-6.12.inc

