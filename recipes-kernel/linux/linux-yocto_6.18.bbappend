require realsense-linux-6.18.inc

