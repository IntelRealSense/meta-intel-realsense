inherit distutils
require python-pyrealsense2.inc
