inherit setuptools3
require python-pyrealsense2.inc
