require librealsense-linux-5.2.inc
