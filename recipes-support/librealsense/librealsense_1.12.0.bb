require librealsense.inc

SRC_URI = "git://github.com/IntelRealSense/librealsense.git;branch=master"
SRCREV = "5c24f5eb3a35b300ff16f98124a044a8a5936db6"

PR = "r0"

S = "${WORKDIR}/git"
