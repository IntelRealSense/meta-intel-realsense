require realsense-linux-6.6.inc
