inherit distutils3
require python-pyrealsense2.inc
